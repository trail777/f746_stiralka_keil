# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ../../gui/include; ..\..\target\include; ..\..\platform\os; ../../generated/fonts/include; ../../generated/images/include; ../../generated/texts/include; ../../generated/gui_generated/include; ../../touchgfx/framework/include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\stm32f7xx; ..\bsp\include\platform\stm32f7xx\CMSIS; ..\bsp\include\platform\stm32f7xx\STM32F7xx_HAL_Driver; ..\bsp\include; ..\bsp\include\vendor; ..\bsp\source\vendor\STM32746G-Discovery; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7; ..\..\widgets\include; ..\..\widgets\LibJPEG\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ../../touchgfx/lib/core/cortex_m7/IAR8.x/touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_SairaCondensed_Medium_14_4bpp_0.cpp Font_SairaCondensed_Medium_16_4bpp_0.cpp Font_SairaCondensed_Medium_22_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_SairaCondensed_Medium_14_4bpp.cpp Kerning_SairaCondensed_Medium_16_4bpp.cpp Kerning_SairaCondensed_Medium_22_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_SairaCondensed_Medium_14_4bpp.cpp Table_SairaCondensed_Medium_16_4bpp.cpp Table_SairaCondensed_Medium_22_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/generated/gui_generated/about_screen
    ../../generated/gui_generated/src/about_screen/: AboutViewBase.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/generated/gui_generated/screensaver_screen
    ../../generated/gui_generated/src/screensaver_screen/: ScreenSaverViewBase.cpp
  group Application/generated/gui_generated/video_screen
    ../../generated/gui_generated/src/video_screen/: VideoViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: allergy.cpp back_arrow.cpp back_center_gray.cpp back_center_white.cpp background.cpp BitmapDatabase.cpp blue_done.cpp blue_start.cpp bottom_bar.cpp buttom_arrow.cpp eco_wash.cpp heat_60.cpp icon_about_40px.cpp icon_center_activewear.cpp icon_center_activewear_medium.cpp icon_center_delicates.cpp icon_center_delicates_medium.cpp icon_center_ecowash.cpp icon_center_ecowash_medium.cpp icon_center_heavyduty.cpp icon_center_heavyduty_medium.cpp icon_center_normal.cpp icon_center_normal_medium.cpp icon_center_quickwash.cpp icon_center_quickwash_medium.cpp icon_center_smartwash.cpp icon_center_smartwash_medium.cpp icon_instructions_40px.cpp left_arrow.cpp pause_stop_button.cpp prewash.cpp right_arrow.cpp running_button.cpp side_gradient_left.cpp side_gradient_right.cpp soil_level_medium.cpp spin_1600.cpp top_bar.cpp top_wash_prewash_active.cpp top_wash_prewash_done.cpp top_wash_prewash_inactive.cpp top_wash_rinsing_active.cpp top_wash_rinsing_done.cpp top_wash_rinsing_inactive.cpp top_wash_spin_cycle_active.cpp top_wash_spin_cycle_done.cpp top_wash_spin_cycle_inactive.cpp top_wash_washing_active.cpp top_wash_washing_done.cpp top_wash_washing_inactive.cpp
  group Application/generated/images/about
    ../../generated/images/src/about/: about_selected.cpp banner.cpp touchgfx_txt.cpp
  group Application/generated/images/center_frames_cropped
    ../../generated/images/src/center_frames_cropped/: Comp_00000.cpp Comp_00001.cpp Comp_00002.cpp Comp_00003.cpp Comp_00004.cpp Comp_00005.cpp Comp_00006.cpp Comp_00007.cpp Comp_00008.cpp Comp_00009.cpp Comp_00010.cpp Comp_00011.cpp Comp_00012.cpp Comp_00013.cpp Comp_00014.cpp Comp_00015.cpp Comp_00016.cpp Comp_00017.cpp Comp_00018.cpp Comp_00019.cpp Comp_00020.cpp Comp_00021.cpp Comp_00022.cpp Comp_00023.cpp Comp_00024.cpp Comp_00025.cpp Comp_00026.cpp
  group Application/generated/images/icons
    ../../generated/images/src/icons/: icon_allergy_50px.cpp icon_eco_wash_50px.cpp icon_heat_20_50px.cpp icon_heat_30_50px.cpp icon_heat_40_50px.cpp icon_heat_60_50px.cpp icon_heat_90_50px.cpp icon_prewash_50px.cpp icon_soil_high_50px.cpp icon_soil_light_50px.cpp icon_soil_medium_50px.cpp icon_spin_speed_1000_rpm_50px.cpp icon_spin_speed_1200_rpm_50px.cpp icon_spin_speed_1400_rpm_50px.cpp icon_spin_speed_1600_rpm_50px.cpp icon_spin_speed_600_rpm_50px.cpp icon_spin_speed_800_rpm_50px.cpp
  group Application/generated/images/instructions
    ../../generated/images/src/instructions/: video_background.cpp video_pause_button.cpp video_play_button.cpp
  group Application/generated/images/screensaver
    ../../generated/images/src/screensaver/: gotoMenu.cpp particle00.cpp particle01.cpp particle02.cpp particle03.cpp particle04.cpp particle05.cpp particle06.cpp particle07.cpp particle08.cpp particle09.cpp particle10.cpp particle2_00.cpp particle2_01.cpp particle2_02.cpp particle2_03.cpp particle2_04.cpp particle2_05.cpp particle2_06.cpp particle2_07.cpp particle2_08.cpp particle2_09.cpp particle2_10.cpp screensaver_background.cpp TGFX_shadow_logo.cpp
  group Application/generated/images/wash_frames
    ../../generated/images/src/wash_frames/: wash_frame_01.cpp wash_frame_02.cpp wash_frame_03.cpp wash_frame_04.cpp wash_frame_05.cpp wash_frame_06.cpp wash_frame_07.cpp wash_frame_08.cpp wash_frame_09.cpp wash_frame_10.cpp wash_frame_11.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/about_screen
    ../../gui/src/about_screen/: AboutPresenter.cpp AboutView.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp Programs.cpp
  group Application/gui/common/ScrollingMenu
    ../../gui/src/common/ScrollingMenu/: ClickableContainer.cpp ScrollingMenu.cpp SparseContainerList.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp TouchForwarder.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/screensaver_screen
    ../../gui/src/screensaver_screen/: ParticleEffect.cpp ScreenSaverPresenter.cpp ScreenSaverView.cpp
  group Application/gui/video_screen
    ../../gui/src/video_screen/: video.c VideoPresenter.cpp VideoView.cpp
  group Application/main
    ../: main.cpp
  group Application/video
    ../../widgets/src/: JPEGFile.cpp MJPEGWidget.cpp
  group Application/video/LibJPEG
    ../../widgets/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Board/STM32F746G-DISCO
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../bsp/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../bsp/source/platform/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
