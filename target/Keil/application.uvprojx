# Keil uVision project application.uvprojx, settings and files
target STM32F746G-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --only=ExtFlashSection --bin --output=binary .\Flash\application.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../../platform/os;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/stm32f7xx;../bsp/include/platform/stm32f7xx/CMSIS;../bsp/include/platform/stm32f7xx/STM32F7xx_HAL_Driver;../bsp/include;../bsp/include/vendor;../bsp/source/vendor/STM32746G-Discovery;../os/FreeRTOS8.2.0/Source/include;../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7;../../widgets/include;../../widgets/LibJPEG/include;../../touchgfx/framework/include;../../generated/fonts/include;../../generated/gui_generated/include;../../generated/images/include;../../generated/texts/include;../../gui/include
  asm include: ../os/FreeRTOSV8.2.0/FreeRTOS/Source/include;../os/FreeRTOSV8.2.0/FreeRTOS/Source/portable/RVDS/ST_CM7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Flash_QSPI.sct
  group Startup
    ../: main.cpp
    ../bsp/source/platform/stm32f7xx/CMSIS/: system_stm32f7xx.c
    ../bsp/source/platform/stm32f7xx/Keil/: startup_stm32f746xx.s
  group TouchGFXHAL
    ../bsp/source/platform/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../bsp/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
  group OS
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group HAL
    ../bsp/source/vendor/Components/ft5336/: ft5336.c
    ../bsp/source/platform/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Lib
    ../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/about_screen/: aboutpresenter.cpp aboutview.cpp
    ../../gui/src/common/scrollingmenu/: clickablecontainer.cpp scrollingmenu.cpp sparsecontainerlist.cpp
    ../../gui/src/common/: frontendapplication.cpp programs.cpp
    ../../gui/src/main_screen/: mainpresenter.cpp mainview.cpp touchforwarder.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screensaver_screen/: particleeffect.cpp screensaverpresenter.cpp screensaverview.cpp
    ../../gui/src/video_screen/: video.c videopresenter.cpp videoview.cpp
  group generated
    ../../generated/images/src/about/: about_selected.cpp banner.cpp touchgfx_txt.cpp
    ../../generated/gui_generated/src/about_screen/: aboutviewbase.cpp
    ../../generated/images/src/: allergy.cpp back_arrow.cpp back_center_gray.cpp back_center_white.cpp background.cpp bitmapdatabase.cpp blue_done.cpp blue_start.cpp bottom_bar.cpp buttom_arrow.cpp eco_wash.cpp heat_60.cpp icon_about_40px.cpp icon_center_activewear.cpp icon_center_activewear_medium.cpp icon_center_delicates.cpp icon_center_delicates_medium.cpp icon_center_ecowash.cpp icon_center_ecowash_medium.cpp icon_center_heavyduty.cpp icon_center_heavyduty_medium.cpp icon_center_normal.cpp icon_center_normal_medium.cpp icon_center_quickwash.cpp icon_center_quickwash_medium.cpp icon_center_smartwash.cpp icon_center_smartwash_medium.cpp icon_instructions_40px.cpp left_arrow.cpp pause_stop_button.cpp prewash.cpp right_arrow.cpp running_button.cpp side_gradient_left.cpp side_gradient_right.cpp soil_level_medium.cpp spin_1600.cpp top_bar.cpp top_wash_prewash_active.cpp top_wash_prewash_done.cpp top_wash_prewash_inactive.cpp top_wash_rinsing_active.cpp top_wash_rinsing_done.cpp top_wash_rinsing_inactive.cpp top_wash_spin_cycle_active.cpp top_wash_spin_cycle_done.cpp top_wash_spin_cycle_inactive.cpp top_wash_washing_active.cpp top_wash_washing_done.cpp top_wash_washing_inactive.cpp
    ../../generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_sairacondensed_medium_14_4bpp_0.cpp font_sairacondensed_medium_16_4bpp_0.cpp font_sairacondensed_medium_22_4bpp_0.cpp font_verdana_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_sairacondensed_medium_14_4bpp.cpp kerning_sairacondensed_medium_16_4bpp.cpp kerning_sairacondensed_medium_22_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_sairacondensed_medium_14_4bpp.cpp table_sairacondensed_medium_16_4bpp.cpp table_sairacondensed_medium_22_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../../generated/images/src/center_frames_cropped/: comp_00000.cpp comp_00001.cpp comp_00002.cpp comp_00003.cpp comp_00004.cpp comp_00005.cpp comp_00006.cpp comp_00007.cpp comp_00008.cpp comp_00009.cpp comp_00010.cpp comp_00011.cpp comp_00012.cpp comp_00013.cpp comp_00014.cpp comp_00015.cpp comp_00016.cpp comp_00017.cpp comp_00018.cpp comp_00019.cpp comp_00020.cpp comp_00021.cpp comp_00022.cpp comp_00023.cpp comp_00024.cpp comp_00025.cpp comp_00026.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/images/src/screensaver/: gotomenu.cpp particle00.cpp particle01.cpp particle02.cpp particle03.cpp particle04.cpp particle05.cpp particle06.cpp particle07.cpp particle08.cpp particle09.cpp particle10.cpp particle2_00.cpp particle2_01.cpp particle2_02.cpp particle2_03.cpp particle2_04.cpp particle2_05.cpp particle2_06.cpp particle2_07.cpp particle2_08.cpp particle2_09.cpp particle2_10.cpp screensaver_background.cpp tgfx_shadow_logo.cpp
    ../../generated/images/src/icons/: icon_allergy_50px.cpp icon_eco_wash_50px.cpp icon_heat_20_50px.cpp icon_heat_30_50px.cpp icon_heat_40_50px.cpp icon_heat_60_50px.cpp icon_heat_90_50px.cpp icon_prewash_50px.cpp icon_soil_high_50px.cpp icon_soil_light_50px.cpp icon_soil_medium_50px.cpp icon_spin_speed_1000_rpm_50px.cpp icon_spin_speed_1200_rpm_50px.cpp icon_spin_speed_1400_rpm_50px.cpp icon_spin_speed_1600_rpm_50px.cpp icon_spin_speed_600_rpm_50px.cpp icon_spin_speed_800_rpm_50px.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../../generated/gui_generated/src/screensaver_screen/: screensaverviewbase.cpp
    ../../generated/images/src/instructions/: video_background.cpp video_pause_button.cpp video_play_button.cpp
    ../../generated/gui_generated/src/video_screen/: videoviewbase.cpp
    ../../generated/images/src/wash_frames/: wash_frame_01.cpp wash_frame_02.cpp wash_frame_03.cpp wash_frame_04.cpp wash_frame_05.cpp wash_frame_06.cpp wash_frame_07.cpp wash_frame_08.cpp wash_frame_09.cpp wash_frame_10.cpp wash_frame_11.cpp
  group Widgets
    ../../widgets/src/: JPEGFile.cpp MJPEGWidget.cpp
  group LibJPEG
    ../../widgets/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c jdatadst.c
